PROGRAM MAIN
VAR
	bBool1: BOOL := FALSE;
END_VAR

END_PROGRAM
